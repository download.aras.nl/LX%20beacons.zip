Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2022-11-04T10:32:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 04 10:32:58 2022 * Host: LIS-C-00085 * Database: C:\Users\JAL1OVR\AppData\Local\Temp\{F0089DE9-097C-4615-B6F6-AD03177BDD35}\ifc * Database version: 5507 * Database creation date: Fri Nov 04 10:32:58 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 04 10:32:58 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 04 10:32:58 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Bauherr; Project Address: Projektadresse; Project Issue Date: Projekt Datum; Project Name: Projektname; Project Number: Projektnummer; Project Status: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Ebene
Graphics(Type) - Color: 16711680; Line Pattern: Verdeckt; Line Weight: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 m
Dimensions - Computation Height: 0 m
Identity Data - Building Story: yes; Name: Ebene 0; Structural: no
Other - Category: Levels; Family: Level: Ebene; Family and Type: Level: Ebene; Type: Level: Ebene; Type Id: Level: Ebene

# IfcDistributionControlElement: LX Beacons Conventional, Fire-Products-Bosch_LXBeaconsConventional:SOL-LX-W-WF-R-D_White-flash_beacon_wall_deep_red:394486
In: Ebene 0
Type - PredefinedType: LIGHT; Classification: Pr_75_80_30_97 Visual alarm signal devices (Uniclass 2015); Material: Red
Type - Constraints - Commercial Type Number: SOL-LX-W-WF-R-D; Deep_Base: yes; Default Elevation: 2.1 m; Shallow_Base: no
Type - Identity Data - CTN: SOL-LX-W-WF-R-D; Description: Conventional red beacon for local alarm indication with deep base and white flashing. Wall-mount.; Disclaimer: https://resources-boschsecurity-cdn.azureedge.net/public/information/bim/Disclaimer.pdf; InstallationManual: Na; Manufacturer: Bosch Security and Safety Systems; OmniClass Number: 23.85.30.21.11.11; OmniClass Title: Fire/Smoke Detectors; PlanningTools: https://media.boschsecurity.com/fs/media/pb/media/support_1/tools/safety-systems-designer.zip; Product Information: https://resources-boschsecurity-cdn.azureedge.net/public/documents/LX_Beacons_Conventio_Data_sheet_enUS_87416684043.pdf; Product Website: https://commerce.boschsecurity.com/nlexp/en/LX-Beacons-Conventional/p/12388176267/; Type Name: SOL-LX-W-WF-R-D_White-flash_beacon_wall_deep_red
Type - Other - Category: Fire Alarm Devices; Color: Red; Dimension in mm (Ø x D): 93 mm x 66 mm; Family Name: Fire-Products-Bosch_LXBeaconsConventional; IP rating: IP65; Material: Plastic; Operating temperature (°C): -25ºC - +70ºC; Operating voltage (VDC): 9 - 60 V DC; Weight (g): 100 g
Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security and Safety Systems
Constraints - Elevation: 0 m; Host: Level : Ebene 0; Level: Level: Ebene 0
Dimensions - Area: 0.0162086 m2; Volume: 0.000438621 m3
Identity Data - Mark: 1
Other - Family: Fire-Products-Bosch_LXBeaconsConventional: SOL-LX-W-WF-R-D_White-flash_beacon_wall_deep_red; Family and Type: Fire-Products-Bosch_LXBeaconsConventional: SOL-LX-W-WF-R-D_White-flash_beacon_wall_deep_red; Schedule Level: Level: Ebene 0; Type: Fire-Products-Bosch_LXBeaconsConventional: SOL-LX-W-WF-R-D_White-flash_beacon_wall_deep_red; Type Id: Fire-Products-Bosch_LXBeaconsConventional: SOL-LX-W-WF-R-D_White-flash_beacon_wall_deep_red
Phasing - Phase Created: Phase 1
